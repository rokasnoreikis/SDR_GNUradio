options:
  parameters:
    generate_options: qt_gui
    id: QT_B210
    output_language: python
    title: USRP_B210
  states: {}

blocks:
- name: Bandwidth
  id: variable_qtgui_range
  parameters:
    start: 10e6
    step: '1'
    stop: 50e6
    value: 20e6
  states: {}
- name: RF_GAIN
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '62'
    value: '40'
  states: {}
- name: amp2
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '10'
    value: '1'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    start: '500'
    step: '1'
    stop: '6000'
    value: '850'
  states: {}
- name: freq2
  id: variable_qtgui_range
  parameters:
    start: 100e3
    step: 100e3
    stop: 1e6
    value: 100e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: amp2
    freq: freq2
    offset: '0'
    phase: '0'
    samp_rate: 2e6
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '-10'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'True'
    filter_source: '''Auto'''
    frequency: int(2500e6)
    len_tag_key: packet_len
    samplerate: int(samp_rate)
    type: fc32
    uri: ip:192.168.2.1
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '5'
    type: ccc
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    ant1: '"RX2"'
    bw0: 20e6
    bw1: 20e6
    center_freq0: freq*1e6
    center_freq1: freq*1e6
    dev_args: '""'
    gain0: RF_GAIN
    gain1: RF_GAIN
    nchan: '2'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0, '0']
- [analog_sig_source_x_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', iio_pluto_sink_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_1, '0']
- [uhd_usrp_source_0, '1', qtgui_freq_sink_x_1, '1']

metadata:
  file_format: 1
